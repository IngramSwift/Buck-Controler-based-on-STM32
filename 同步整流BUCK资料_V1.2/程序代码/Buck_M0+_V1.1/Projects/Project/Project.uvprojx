# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,ARM_MATH_CM0, USE_USART_PRINTF=0
  c include: ..\..\Libraries\CMSIS\Device\Include;..\..\Libraries\CMSIS\Device\Source;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\CMSIS_RTOS;..\..\Utilities\inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Std_Library
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crc.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_flash.c
  group CMSIS
    ../../Libraries/CMSIS/Device/Source/: startup_stm32f030.s
    ../user/: system_stm32f0xx.c
  group User_App
    ../user/: main.c stm32f0xx_it.c freeRTOS_task.c
    ../../Utilities/src/: delay.c led.c key.c adc.c timer.c pwm.c myiic.c oled.c pid.c vi_control.c calibration.c fuzzy_pid.c
  group FreeRTOS
    ../../FreeRTOS/Source/: list.c timers.c croutine.c queue.c tasks.c event_groups.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
